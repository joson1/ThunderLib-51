# Keil uVision project thunderLib.uvproj, settings and files
target ThunderLib (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: thunderLib
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\inc;..\..\ThunderLib
  group src
    ../src/: ADC.c common.c IIC.c Pwm.c Timer.c Uart.c
